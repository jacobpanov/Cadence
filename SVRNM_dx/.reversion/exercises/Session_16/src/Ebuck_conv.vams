// --- Begin Copyright Block -----[ do not move or remove ]------
// Copyright (c) 2020, Cadence Design Systems, Inc. All rights reserved.

// The model contained herein is the proprietary and confidential information 
// of Cadence, and is supplied subject to, and may be used only by Cadences 
// customer in accordance with a previously executed license and maintenance 
// agreement between Cadence and that customer. This model is intended for use 
// with products only from Cadence Design Systems, Inc.  The use or sharing of 
// any models from this library or any of its modified/extended form is 
// strictly prohibited with any non-Cadence products.

// ALL MATERIALS FURNISHED BY CADENCE HEREUNDER ARE PROVIDED "AS IS" WITHOUT 
// WARRANTY OF ANY KIND, AND CADENCE SPECIFICALLY DISCLAIMS ANY WARRANTY OF 
// NONINFRINGEMENT, FITNESS FOR A PARTICULAR PURPOSE OR MERCHANTABILITY. 
// CADENCE SHALL NOT BE LIABLE FOR ANY COSTS OF PROCUREMENT OF SUBSTITUTES, 
// LOSS OF PROFITS, INTERRUPTION OF BUSINESS, OR FOR ANY OTHER SPECIAL, 
// CONSEQUENTIAL OR INCIDENTAL DAMAGES, HOWEVER CAUSED, WHETHER FOR BREACH OF 
// WARRANTY, CONTRACT, TORT, NEGLIGENCE, STRICT LIABILITY OR OTHERWISE.
// --------------------------------------------------------------
//
// buck mode DC/DC converter model (VerilogAMS version)
//               CK
//            ...|......................
//    Iin->   : _v_    IL->  L         :  Iout->
//    __________---___ _____ooo___ ______________ 
//   |   [IN] :      _|_[M]      _|_   : [OUT]   |   
//  Vs        :   dio/_\        C---   :        RL 
//   |        :       |           |    :         |  
//   v        :       v           v    :         v
//            :........................:
// Clock (CK):  period [Per], duty cycle [Duty]
// Diode:  on voltage [Vd], on resistance [Rd]
// Switch: on resistance [Rsw], switch time [Tsw]
// Inductor [L], current tolerance [itol]
// Capacitor [C], voltage tolerance [vtol]  

`include "disciplines.vams"

module Ebuck_conv(OUT,IN,CK);
  output OUT; electrical OUT;   // output electrical net
  input IN; electrical IN;      // input electrical net (supply)
  input CK;                     // digital clock input

parameter real L=1e-3;    // inductor value
parameter real C=0.2e-6;  // capacitor value
parameter real Rsw=0.1;   // on resistance of switch
parameter real Tsw=10e-9; // rise/fall time of switch
parameter real Rd=0.1;    // on resistance of diode
parameter real Vd=0.2;    // on voltage of diode
parameter real Roff=1e9;  // off resistance of diode & switch

electrical M,GND;         // internal nodes within module
ground GND;               // drive ground node to zero

// ELECTRICAL NETLIST:
ESwitD  #(.ron(Rsw), .roff(Roff), .tr(Tsw))  Swt(IN,M,CK);
EDIO_EE #(.von(Vd), .ron(Rd), .roff(Roff))   Dio(GND,M);
EIndD   #(.l(L), .ic(0))                     Ind(M,OUT);
ECapG   #(.c(C), .ic(0))                     Cap(OUT);

endmodule

