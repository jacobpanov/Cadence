// --- Begin Copyright Block -----[ do not move or remove ]------
// Copyright (c) 2019, Cadence Design Systems, Inc. All rights reserved.

// The model contained herein is the proprietary and confidential information 
// of Cadence, and is supplied subject to, and may be used only by Cadences 
// customer in accordance with a previously executed license and maintenance 
// agreement between Cadence and that customer. This model is intended for use 
// with products only from Cadence Design Systems, Inc.  The use or sharing of 
// any models from this library or any of its modified/extended form is 
// strictly prohibited with any non-Cadence products.

// ALL MATERIALS FURNISHED BY CADENCE HEREUNDER ARE PROVIDED "AS IS" WITHOUT 
// WARRANTY OF ANY KIND, AND CADENCE SPECIFICALLY DISCLAIMS ANY WARRANTY OF 
// NONINFRINGEMENT, FITNESS FOR A PARTICULAR PURPOSE OR MERCHANTABILITY. 
// CADENCE SHALL NOT BE LIABLE FOR ANY COSTS OF PROCUREMENT OF SUBSTITUTES, 
// LOSS OF PROFITS, INTERRUPTION OF BUSINESS, OR FOR ANY OTHER SPECIAL, 
// CONSEQUENTIAL OR INCIDENTAL DAMAGES, HOWEVER CAUSED, WHETHER FOR BREACH OF 
// WARRANTY, CONTRACT, TORT, NEGLIGENCE, STRICT LIABILITY OR OTHERWISE.
// --------------------------------------------------------------

// AMS netlist generated by the OSS based AMS netlister


`include "disciplines.vams"
`include "userDisciplines.vams"

`timescale 1ns / 1ps 

module amsTB ();

  // TB Nets
  wire iRes, VOUT;

  vsource #(.type("sine"), 
    .ampl("1.0"),
    .freq("1M")
    ) V0 (VIN, cds_globals.\gnd! );


  resDemo u_resDemo ( 
    .PLUS(VIN), 
    .MINUS(cds_globals.\gnd! ), 
    .VOUT (VOUT), 
    .iRes (iRes)
    );

  resMeas resMeas (VOUT);

  initial begin
    #(20e3); $finish;
  end

endmodule
